# Keil uVision project iic_master_s_mck_ra8t1_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: R7FA8T1AH Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: iic_master_s_mck_ra8t1_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" "$PUserNscApiFiles.txt" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=6
  c define: _RA_TZ_SECURE
  c misc: @via/rasc_armclang.via
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: g_i2c_master_guard.c hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
