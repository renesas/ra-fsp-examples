# IAR project usb_phid_ns_mck_ra8t1_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA8T1AH Renesas R7FA8T1AH
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/aws/FreeRTOS/FreeRTOS/Source/include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra/fsp/src/r_usb_basic/src/driver/inc; ra/fsp/src/rm_freertos_port; ra_cfg/aws; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_phid_ns_mck_ra8t1_ep.hex
  ILINK.IlinkOutputFile: usb_phid_ns_mck_ra8t1_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"; -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ra_cfg/aws/: FreeRTOSConfig.h
    ra_cfg/fsp_cfg/: r_ioport_cfg.h r_usb_basic_cfg.h r_usb_class_cfg.h r_usb_phid_cfg.h
  group Flex Software/Components
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/aws/FreeRTOS/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ra/board/ra8t1_mck/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    ra/fsp/src/bsp/mcu/all/: board_sdram.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ioport_api.h r_transfer_api.h r_usb_basic_api.h r_usb_phid_api.h
    ra/fsp/src/bsp/mcu/ra8t1/: bsp_elc.h bsp_feature.h bsp_feature_gen.h bsp_mcu_info.h bsp_override.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/aws/FreeRTOS/FreeRTOS/Source/: event_groups.c LICENSE.md list.c queue.c stream_buffer.c tasks.c timers.c
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/aws/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ra/arm/CMSIS_6/: LICENSE
    ra/aws/FreeRTOS/: LICENSE.md
    ra/fsp/src/rm_freertos_port/: port.c portmacro.h
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA8T1AH.h renesas.h system.h
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/inc/instances/: r_ioport.h r_usb_basic.h
    ra/fsp/src/r_usb_basic/: r_usb_basic.c
    ra/fsp/src/r_usb_basic/src/driver/inc/: r_usb_basic_define.h r_usb_cstd_rtos.h r_usb_extern.h r_usb_typedef.h
    ra/fsp/src/r_usb_basic/src/hw/inc/: r_usb_bitdefine.h r_usb_dmac.h r_usb_reg_access.h
    ra/fsp/src/r_usb_basic/src/driver/: r_usb_cdataio.c r_usb_clibusbip.c r_usb_cstd_rtos.c r_usb_hbc.c r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hinthandler_usbip0.c r_usb_hinthandler_usbip1.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hscheduler.c r_usb_hsignal.c r_usb_hstdfunction.c r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pintfifo.c r_usb_pinthandler_usbip0.c r_usb_plibusbip.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c
    ra/fsp/src/r_usb_basic/src/hw/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_dma.c r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c r_usb_mcu.c r_usb_preg_abs.c r_usb_preg_access.c
    ra/fsp/src/r_usb_phid/: r_usb_phid_descriptor_keyboard.c.template r_usb_phid_descriptor_mouse.c.template
    ra/fsp/src/r_usb_phid/src/: r_usb_phid_driver.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c phid_main_thread.c phid_main_thread.h pin_data.c rtt_input_thread.c rtt_input_thread.h vector_data.c vector_data.h
  group Flex Software/Objects
    ./: secure.o
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c phid_main_thread_entry.c r_usb_phid_descriptor.c rtt_input_thread_entry.c usb_phid_ep.h
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
