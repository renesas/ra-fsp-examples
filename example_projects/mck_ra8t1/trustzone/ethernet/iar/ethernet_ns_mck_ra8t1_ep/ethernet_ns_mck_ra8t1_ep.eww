<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\ethernet_ns_mck_ra8t1_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\ethernet_s_mck_ra8t1_ep\ethernet_s_mck_ra8t1_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>ethernet_s_mck_ra8t1_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ethernet_ns_mck_ra8t1_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
