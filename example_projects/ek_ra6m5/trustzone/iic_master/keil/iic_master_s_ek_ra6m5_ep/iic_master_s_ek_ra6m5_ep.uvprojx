# Keil uVision project iic_master_s_ek_ra6m5_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: iic_master_s_ek_ra6m5_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" "$PUserNscApiFiles.txt" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: _RA_TZ_SECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: g_i2c_master_guard.c hal_entry.c g_i2c_master0_guard.c.bak
software components: Flex Software:RA Configuration 1.0.0
