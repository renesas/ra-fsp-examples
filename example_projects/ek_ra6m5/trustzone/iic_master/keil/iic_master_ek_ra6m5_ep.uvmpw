<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>C:\build_5.3.0\example_projects\ek_ra6m5\trustzone\iic_master\keil\iic_master_ek_ra6m5_ep.uvmpw</WorkspaceName>

  <project>
    <PathAndName>.\iic_master_ns_ek_ra6m5_ep\iic_master_ns_ek_ra6m5_ep.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\iic_master_s_ek_ra6m5_ep\iic_master_s_ek_ra6m5_ep.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
