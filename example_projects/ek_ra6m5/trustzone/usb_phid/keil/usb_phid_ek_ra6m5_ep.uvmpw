<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\usb_phid_s_ek_ra6m5_ep\usb_phid_s_ek_ra6m5_ep.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\usb_phid_ns_ek_ra6m5_ep\usb_phid_ns_ek_ra6m5_ep.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

</ProjectWorkspace>
