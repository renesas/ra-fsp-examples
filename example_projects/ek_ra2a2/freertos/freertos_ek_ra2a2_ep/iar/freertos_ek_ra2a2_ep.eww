<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\freertos_ek_ra2a2_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
