# IAR project lpm_ek_ra4m3_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA4M3AF Renesas R7FA4M3AF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: _RENESAS_RA_; _RA_CORE=CM33; _RA_ORDINAL=1
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_; _RA_CORE=CM33; _RA_ORDINAL=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lpm_ek_ra4m3_ep.hex
  ILINK.IlinkOutputFile: lpm_ek_ra4m3_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"; -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_; _RA_CORE=CM33; _RA_ORDINAL=1
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_agt_cfg.h r_dtc_cfg.h r_icu_cfg.h r_ioport_cfg.h r_lpm_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/board/ra4m3_ek/: board.h board_init.c board_init.h board_leds.c board_leds.h
    ra/fsp/src/bsp/mcu/all/: board_sdram.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_mmf.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_external_irq_api.h r_ioport_api.h r_lpm_api.h r_timer_api.h r_transfer_api.h r_uart_api.h
    ra/fsp/src/bsp/mcu/ra4m3/: bsp_elc.h bsp_feature.h bsp_feature_gen.h bsp_mcu_info.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/arm/CMSIS_6/: LICENSE
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA4M3AF.h renesas.h system.h
    ra/fsp/src/r_agt/: r_agt.c
    ra/fsp/inc/instances/: r_agt.h r_dtc.h r_icu.h r_ioport.h r_lpm.h r_sci_uart.h
    ra/fsp/src/r_dtc/: r_dtc.c
    ra/fsp/src/r_icu/: r_icu.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_lpm/: r_lpm.c
    ra/fsp/src/r_sci_uart/: r_sci_uart.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c lpm_ep.c lpm_ep.h source_cancel_lpm.c source_cancel_lpm.h uart_terminal.c uart_terminal.h
