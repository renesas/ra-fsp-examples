<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_ek_ra4m3_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
