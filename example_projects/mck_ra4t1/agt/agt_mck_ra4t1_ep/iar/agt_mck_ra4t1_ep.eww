<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\dmac\dmac_mck_ra4t1_ep\iar\dmac_mck_ra4t1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
