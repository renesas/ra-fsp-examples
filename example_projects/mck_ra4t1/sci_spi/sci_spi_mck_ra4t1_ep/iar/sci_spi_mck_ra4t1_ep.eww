<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\sci_spi_mck_ra4t1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
