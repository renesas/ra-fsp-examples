<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\dmac_ek_ra8d2_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
