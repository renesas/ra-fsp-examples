<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\gpt_fpb_ra2e3_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
