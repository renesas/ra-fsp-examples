<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\flash_lp_fpb_ra2t1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
