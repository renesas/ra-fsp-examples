# Keil uVision project iic_master_ns_ek_ra4l1_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: R7FA4L1BD Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: iic_master_ns_ek_ra4l1_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: _RA_TZ_NONSECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group CMSE Import Library
    ./: secure.o
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: common_utils.h hal_entry.c i2c_sensor.c i2c_sensor.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
