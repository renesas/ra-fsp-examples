<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\iic_master_s_ek_ra4l1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
