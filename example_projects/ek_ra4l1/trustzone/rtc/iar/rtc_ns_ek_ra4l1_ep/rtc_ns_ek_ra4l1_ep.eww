<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtc_ns_ek_ra4l1_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\rtc_s_ek_ra4l1_ep\rtc_s_ek_ra4l1_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>rtc_s_ek_ra4l1_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>rtc_ns_ek_ra4l1_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
