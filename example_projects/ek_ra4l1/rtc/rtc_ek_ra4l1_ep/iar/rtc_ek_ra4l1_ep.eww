<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtc_ek_ra4l1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
