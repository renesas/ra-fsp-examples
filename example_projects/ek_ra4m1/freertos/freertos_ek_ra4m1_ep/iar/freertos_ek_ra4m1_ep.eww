<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\freertos_ek_ra4m1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
