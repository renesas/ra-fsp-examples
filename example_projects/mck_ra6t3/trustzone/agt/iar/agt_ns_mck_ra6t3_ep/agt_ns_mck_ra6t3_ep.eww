<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\agt_ns_mck_ra6t3_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\agt_s_mck_ra6t3_ep\agt_s_mck_ra6t3_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>agt_s_mck_ra6t3_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>agt_ns_mck_ra6t3_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
