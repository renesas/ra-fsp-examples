<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\agt_s_mck_ra6t3_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
