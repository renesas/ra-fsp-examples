# Keil uVision project agt_s_fpb_ra8e1_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA8E1AF Renesas
  pack: Renesas.RA_DFP.6.7.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: agt_s_fpb_ra8e1_ep +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" "$PUserNscApiFiles.txt" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c define: _RA_TZ_SECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c custom_guard.h g_timer_one_shot_guard.c g_timer_periodic_guard.c
software components: Flex Software:RA Configuration 1.0.0
