# Keil uVision project iic_master_ns_fpb_ra8e1_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA8E1AF Renesas
  pack: Renesas.RA_DFP.6.7.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: iic_master_ns_fpb_ra8e1_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c define: _RA_TZ_NONSECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group CMSE Import Library
    ./: secure.o
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: common_utils.h hal_entry.c i2c_sensor.c i2c_sensor.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
