<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\wdt_ek_ra8p1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
