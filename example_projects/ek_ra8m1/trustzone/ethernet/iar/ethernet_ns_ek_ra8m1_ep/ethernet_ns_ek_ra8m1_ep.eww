<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\ethernet_ns_ek_ra8m1_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\ethernet_s_ek_ra8m1_ep\ethernet_s_ek_ra8m1_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>ethernet_s_ek_ra8m1_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ethernet_ns_ek_ra8m1_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
