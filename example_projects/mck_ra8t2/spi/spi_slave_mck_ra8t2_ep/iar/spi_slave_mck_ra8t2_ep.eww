<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_slave_mck_ra8t2_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
