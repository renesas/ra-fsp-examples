# Keil uVision project usb_phid_ns_mck_ra8t2_ep.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8T2LF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: usb_phid_ns_mck_ra8t2_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: _RA_TZ_NONSECURE
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group CMSE Import Library
    ./: secure.o
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c phid_main_thread_entry.c rtt_input_thread_entry.c common_utils.h r_usb_phid_descriptor.c usb_phid_ep.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
