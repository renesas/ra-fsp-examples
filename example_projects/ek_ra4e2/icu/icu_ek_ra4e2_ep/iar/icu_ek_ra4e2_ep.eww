<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\icu_ek_ra4e2_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
