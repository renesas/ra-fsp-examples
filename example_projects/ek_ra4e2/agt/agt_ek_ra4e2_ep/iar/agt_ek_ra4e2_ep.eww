<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\ek_ra6e2\wdt\wdt_ek_ra6e2_ep\iar\wdt_ek_ra6e2_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
