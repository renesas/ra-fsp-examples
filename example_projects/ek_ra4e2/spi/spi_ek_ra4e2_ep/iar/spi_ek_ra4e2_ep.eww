<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_ek_ra4e2_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\ek_ra6e2\spi\spi_ek_ra6e2_ep\iar\spi_ek_ra6e2_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
