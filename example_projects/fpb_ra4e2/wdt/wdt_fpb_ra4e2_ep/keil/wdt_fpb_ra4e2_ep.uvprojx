# Keil uVision project wdt_fpb_ra4e2_ep.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA4E2B9 Renesas
  pack: Renesas.RA_DFP.6.7.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: wdt_fpb_ra4e2_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/console/: syscalls_keil.c uart_console.c uart_console.h
    ./src/: ext_irq_setup.c ext_irq_setup.h hal_entry.c hal_warmstart.c timer_setup.c timer_setup.h wdt_ep.c wdt_ep.h wdt_example_app.c wdt_example_app.h
software components: Flex Software:RA Configuration 1.0.0
