<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gpt_ek_ra6m3g_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
