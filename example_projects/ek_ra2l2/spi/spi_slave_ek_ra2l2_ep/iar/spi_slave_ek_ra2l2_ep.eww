<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\ek_ra4l1\spi\spi_slave_ek_ra4l1_ep\iar\spi_slave_ek_ra4l1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
