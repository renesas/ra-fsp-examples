# IAR project ethernet_ek_ra6m3_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6M3AH Renesas R7FA6M3AH
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; ra/aws/amazon-freertos/freertos_kernel/include; ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include; ra/fsp/src/rm_freertos_plus_tcp; ra/fsp/src/rm_freertos_port; ra_cfg/aws
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ethernet_ek_ra6m3_ep.hex
  ILINK.IlinkOutputFile: ethernet_ek_ra6m3_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h
    ra_cfg/aws/: FreeRTOSConfig.h FreeRTOSIPConfig.h
    ra_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ioport_cfg.h
  group Flex Software/Components
    ra/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: base_addresses.h renesas.h system.h
    ra/board/ra6m3_ek/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    ra/fsp/inc/api/: bsp_api.h r_ether_api.h r_ether_phy_api.h r_ioport_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h
    ra/fsp/src/bsp/mcu/ra6m3/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/BufferManagement/: BufferAllocation_2.c
    ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ra/aws/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h tcp_dump_packets.h tcp_mem_stats.h
    ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ra/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ra/aws/amazon-freertos/: LICENSE
    ra/arm/CMSIS_5/: LICENSE.txt
    ra/aws/amazon-freertos/freertos_kernel/License/: license.txt
    ra/fsp/src/rm_freertos_plus_tcp/: NetworkInterface.c pack_struct_end.h pack_struct_start.h
    ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/Compiler/GCC/: pack_struct_end.h pack_struct_start.h
    ra/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/Compiler/IAR/: pack_struct_end.h pack_struct_start.h
    ra/fsp/src/rm_freertos_port/: port.c portmacro.h
    ra/fsp/src/r_ether/: r_ether.c
    ra/fsp/inc/instances/: r_ether.h r_ether_phy.h r_ioport.h
    ra/fsp/src/r_ether_phy/: r_ether_phy.c
    ra/fsp/src/r_ether_phy/targets/DP83620/: r_ether_phy_target_dp83620.c
    ra/fsp/src/r_ether_phy/targets/KSZ8041/: r_ether_phy_target_ksz8041.c
    ra/fsp/src/r_ether_phy/targets/KSZ8091RNB/: r_ether_phy_target_ksz8091rnb.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/SVD/: RA.svd
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h bsp_pin_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c net_thread.c net_thread.h pin_data.c RA6M3-EK.csv vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c net_thread_entry.c usr_app.h
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
