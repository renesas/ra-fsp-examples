<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ethernet_ek_ra6m3_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
