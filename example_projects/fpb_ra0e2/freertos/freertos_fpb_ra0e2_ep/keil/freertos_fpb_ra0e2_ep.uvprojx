# Keil uVision project freertos_fpb_ra0e2_ep.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA0E209 Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: freertos_fpb_ra0e2_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: common_utils.h freertos_ep.h hal_entry.c receiver_task_entry.c semaphore_task_entry.c sender_task_entry.c tau_timer_initialize.c tau_timer_initialize.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
