<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sci_uart_ek_ra2a1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
