# Keil uVision project freertos_ek_ra2l1_ep.uvprojx, settings and files
target Target 1 (6160000::V6.16::.\ARM_6.16)
  device: R7FA2L1AB2DFP Renesas
  pack: Renesas.RA_DFP.3.2.0
  cpu: CPUTYPE("Cortex-M23") noFPU2 CLOCK(12000000) ELITTLE
  output: freertos_ek_ra2l1_ep +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal -Os
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: common_utils.h freertos_ep.h gpt_timer_initialize.c gpt_timer_initialize.h hal_entry.c receiver_task_entry.c semaphore_task_entry.c sender_task_entry.c
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
