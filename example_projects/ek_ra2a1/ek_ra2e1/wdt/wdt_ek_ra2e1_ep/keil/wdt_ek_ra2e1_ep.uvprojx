# Keil uVision project wdt_ek_ra2e1_ep.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: R7FA2E1A92DFM Renesas
  pack: Renesas.RA_DFP.2.3.0-rc0
  cpu: CPUTYPE("Cortex-M23") noFPU2 CLOCK(12000000) ELITTLE
  output: wdt_ek_ra2e1_ep +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Os -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c common_utils.h ext_irq_setup.c ext_irq_setup.h timer_setup.c timer_setup.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
