<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\can_ek_ra2a1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
