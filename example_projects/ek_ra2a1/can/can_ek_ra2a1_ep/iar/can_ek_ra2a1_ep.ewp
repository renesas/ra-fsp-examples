# IAR project can_ek_ra2a1_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA2A1AB Renesas R7FA2A1AB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: _RENESAS_RA_
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: can_ek_ra2a1_ep.hex
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily ra "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  ILINK.IlinkOutputFile: can_ek_ra2a1_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_can_cfg.h r_cgc_cfg.h r_ioport_cfg.h
  group Flex Software/Components
    ra/board/ra2a1_ek/: board.h board_init.c board_init.h board_leds.c board_leds.h
    ra/fsp/inc/api/: bsp_api.h r_can_api.h r_cgc_api.h r_ioport_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_arm_exceptions.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra2a1/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
    ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ra/arm/CMSIS_5/: LICENSE.txt
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA2A1AB.h R7FA2E1A9.h R7FA2E2A7.h R7FA2L1AB.h R7FA4E10D.h R7FA4M1AB.h R7FA4M2AD.h R7FA4M3AF.h R7FA4W1AD.h R7FA6E10F.h R7FA6M1AD.h R7FA6M2AF.h R7FA6M3AH.h R7FA6M4AF.h R7FA6M5BH.h R7FA6T1AD.h R7FA6T2BD.h renesas.h system.h
    ra/fsp/src/r_can/: r_can.c
    ra/fsp/inc/instances/: r_can.h r_cgc.h r_ioport.h
    ra/fsp/src/r_cgc/: r_cgc.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
