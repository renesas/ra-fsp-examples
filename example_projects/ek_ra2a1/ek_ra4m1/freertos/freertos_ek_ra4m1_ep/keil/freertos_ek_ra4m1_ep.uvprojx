# Keil uVision project freertos_ek_ra4m1_ep.uvprojx, settings and files
target Target 1 (6160000::V6.16::.\ARM_6.16)
  device: R7FA4M1AB3CFP Renesas
  pack: Renesas.RA_DFP.3.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_ek_ra4m1_ep +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-license-management -Os -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --library_type=microlib --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c receiver_task_entry.c semaphore_task_entry.c sender_task_entry.c common_utils.h freertos_ep.h gpt_timer_initialize.c gpt_timer_initialize.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
