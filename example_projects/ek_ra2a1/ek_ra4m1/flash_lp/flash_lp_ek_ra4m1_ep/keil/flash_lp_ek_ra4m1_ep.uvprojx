# Keil uVision project flash_lp_ek_ra4m1_ep.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::.\ARM6.14)
  device: R7FA4M1AB3CFP Renesas
  pack: Renesas.RA_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flash_lp_ek_ra4m1_ep +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-license-management -Os -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --library_type=microlib --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c common_utils.h flash_lp_ep.c flash_lp_ep.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
