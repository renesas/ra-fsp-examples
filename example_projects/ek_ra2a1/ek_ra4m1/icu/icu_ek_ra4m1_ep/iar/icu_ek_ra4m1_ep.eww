<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\icu_ek_ra4m1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
