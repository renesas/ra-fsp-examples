<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\usb_phid_ns_ek_ra6m4_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\usb_phid_s_ek_ra6m4_ep\usb_phid_s_ek_ra6m4_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>usb_phid_s_ek_ra6m4_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>usb_phid_ns_ek_ra6m4_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
