<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\usb_phid_ns_ek_ra6m4_ep\usb_phid_ns_ek_ra6m4_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb_phid_s_ek_ra6m4_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
