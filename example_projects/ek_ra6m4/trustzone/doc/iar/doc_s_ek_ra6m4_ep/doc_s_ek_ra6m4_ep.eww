<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\doc_ns_ek_ra6m4_ep\doc_ns_ek_ra6m4_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\doc_s_ek_ra6m4_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
