<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\iic_master_ns_ek_ra6m4_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\iic_master_s_ek_ra6m4_ep\iic_master_s_ek_ra6m4_ep.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>iic_master_s_ek_ra6m4_ep</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>iic_master_ns_ek_ra6m4_ep</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
