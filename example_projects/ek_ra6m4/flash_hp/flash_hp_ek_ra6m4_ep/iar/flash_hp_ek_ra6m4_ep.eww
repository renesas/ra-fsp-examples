<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\flash_hp_ek_ra6m4_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
