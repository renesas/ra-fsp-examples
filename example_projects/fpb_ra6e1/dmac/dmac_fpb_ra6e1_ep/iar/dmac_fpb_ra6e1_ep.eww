<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\dmac_fpb_ra6e1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
