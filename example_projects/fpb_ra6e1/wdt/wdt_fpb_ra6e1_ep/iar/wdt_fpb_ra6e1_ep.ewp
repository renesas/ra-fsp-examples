# IAR project wdt_fpb_ra6e1_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: _RENESAS_RA_; _RA_CORE=CM33
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_; _RA_CORE=CM33
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wdt_fpb_ra6e1_ep.hex
  prebuild: cmd /c ""$RASC_EXE_PATH$" --generate --compiler IAR --devicefamily ra "configuration.xml" 2> "%TEMP%\rasc_stderr.out""
  postbuild: cmd /c ""$RASC_EXE_PATH$" --gensecurebundle --compiler IAR --devicefamily ra "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  ILINK.IlinkOutputFile: wdt_fpb_ra6e1_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_; _RA_CORE=CM33
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_gpt_cfg.h r_icu_cfg.h r_ioport_cfg.h r_wdt_cfg.h
  group Flex Software/Components
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: base_addresses.h renesas.h system.h
    ra/board/ra6e1_fpb/: board.h board_init.c board_init.h board_leds.c board_leds.h
    ra/fsp/inc/api/: bsp_api.h r_external_irq_api.h r_ioport_api.h r_timer_api.h r_wdt_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_arm_exceptions.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra6e1/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ra/arm/CMSIS_5/: LICENSE.txt
    ra/fsp/src/r_gpt/: r_gpt.c
    ra/fsp/inc/instances/: r_gpt.h r_icu.h r_ioport.h r_wdt.h
    ra/fsp/src/r_icu/: r_icu.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_wdt/: r_wdt.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h ext_irq_setup.c ext_irq_setup.h hal_entry.c timer_setup.c timer_setup.h
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
