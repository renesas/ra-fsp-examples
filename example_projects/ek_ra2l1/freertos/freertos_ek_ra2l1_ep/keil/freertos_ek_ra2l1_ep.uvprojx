# Keil uVision project freertos_ek_ra2l1_ep.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA2L1AB Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: freertos_ek_ra2l1_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: common_utils.h freertos_ep.h gpt_timer_initialize.c gpt_timer_initialize.h hal_entry.c receiver_task_entry.c semaphore_task_entry.c sender_task_entry.c
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
