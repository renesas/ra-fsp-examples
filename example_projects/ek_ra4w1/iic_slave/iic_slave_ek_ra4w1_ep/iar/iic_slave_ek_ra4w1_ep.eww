<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iic_slave_ek_ra4w1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
