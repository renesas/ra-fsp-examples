<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\usb_phid_s_ek_ra8m2_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
