<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\agt_rssk_ra6t1_ep.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\freertos_ra6t1\freertos_rssk_ra6t1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
