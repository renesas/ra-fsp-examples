<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_rssk_ra6t1_ep.ewp</path>
    </project>
    <batchBuild />
</workspace>
