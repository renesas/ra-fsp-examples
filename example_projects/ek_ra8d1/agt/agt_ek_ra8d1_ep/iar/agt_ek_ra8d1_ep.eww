<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\agt_ek_ra8d1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
