# Keil uVision project agt_s_ek_ra8d1_ep.uvprojx, settings and files
target Target 1 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.6.6.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: agt_s_ek_ra8d1_ep +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" "$PUserNscApiFiles.txt" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: _RA_TZ_SECURE
  c misc: @via/rasc_armclang.via
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: g_timer_one_shot_guard.c g_timer_periodic_guard.c hal_entry.c custom_guard.h
software components: Flex Software:RA Configuration 1.0.0
