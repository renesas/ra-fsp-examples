<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\doc_s_ek_ra4c1_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
