# Keil uVision project sensor_ns.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA8M1AH Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: sensor_ns +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=3
  c define: _RA_TZ_NONSECURE
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group CMSE Import Library
    ./: secure.o
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c app_definitions.h common_utils.h sensor_algorithm_nsc.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
