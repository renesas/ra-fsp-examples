<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_ns.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\sensor_s\sensor_s.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TrustZone Projects</name>
            <member>
                <project>sensor_s</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sensor_ns</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
