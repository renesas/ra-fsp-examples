<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_ns\sensor_ns.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sensor_s\sensor_s.ewp</path>
    </project>
    <batchBuild />
</workspace>
