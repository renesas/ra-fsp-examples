# Keil uVision project sensor_s.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: sensor_s
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.2.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: _RA_TZ_SECURE
  c misc: -mcmse -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via" --import_cmse_lib_out="$Lsecure.o"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c sensor_algorithm_nsc.c sensor_algorithm_nsc.h
software components: Flex Software:RA Configuration 1.0.0
