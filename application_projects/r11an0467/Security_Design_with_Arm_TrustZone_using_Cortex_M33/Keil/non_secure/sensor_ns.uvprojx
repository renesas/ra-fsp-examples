# Keil uVision project sensor_ns.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.5.5.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: sensor_ns +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: _RA_TZ_NONSECURE
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group CMSE Import Library
    ./: secure.o
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c app_definitions.h common_utils.h sensor_algorithm_nsc.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
